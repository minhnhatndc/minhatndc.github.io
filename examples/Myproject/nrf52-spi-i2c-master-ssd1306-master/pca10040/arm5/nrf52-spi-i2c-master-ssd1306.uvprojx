# Keil uVision project nrf52-spi-i2c-master-ssd1306.uvprojx, settings and files
target nrf52832_ssd1306 (5060020::V5.06 (build 20)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_ssd1306 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 SWI_DISABLE0 DEBUG
  c include: ../..
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002800 size 0xd800
  group Application
    ../../: main.c uart_module.c spi_module.c ssd1306.c ssd1306.h
  group Documentation
    ../../: Abstract.txt license.txt
software components: CMSIS:CORE 4.3.0, Board Support:bsp 10.0.0, Device:Startup 8.2.0, nRF_Drivers:app_uart 3.1.0, nRF_Drivers:nrf_delay 3.1.0, nRF_Drivers:nrf_drv_common 3.1.0, nRF_Drivers:nrf_drv_gpiote 3.1.0, nRF_Drivers:nrf_drv_spi 3.1.0, nRF_Drivers:nrf_drv_twi 3.1.0, nRF_Drivers:nrf_drv_uart 3.1.0, nRF_Drivers:nrf_error 3.1.0, nRF_Drivers:nrf_gpio 3.1.0, nRF_Drivers:nrf_gpiote 3.1.0, nRF_Drivers:nrf_spi 3.1.0, nRF_Drivers:nrf_spim 3.1.0, nRF_Drivers:nrf_twi 3.1.0, nRF_Drivers:nrf_uart 3.1.0, nRF_Drivers:nrf_uarte 3.1.0, nRF_Libraries:app_button 3.1.0, nRF_Libraries:app_error 3.1.0, nRF_Libraries:app_fifo 3.1.0, nRF_Libraries:app_timer 3.1.0, nRF_Libraries:app_util 3.1.0, nRF_Libraries:nordic_common 3.1.0, nRF_Libraries:nrf_assert 3.1.0, nRF_Libraries:retarget 3.1.0
